#include "mn_gfx.h"
#include <string.h>
#include <stdlib.h>
#include <math.h>

namespace mn {

uint16_t* fb = nullptr;

// Classic 5x7 column font, ASCII 0x20..0x7E. Bit 0 is the top row.
static const uint8_t FONT[95][5] = {
  {0x00,0x00,0x00,0x00,0x00},{0x00,0x00,0x5F,0x00,0x00},{0x00,0x07,0x00,0x07,0x00},
  {0x14,0x7F,0x14,0x7F,0x14},{0x24,0x2A,0x7F,0x2A,0x12},{0x23,0x13,0x08,0x64,0x62},
  {0x36,0x49,0x56,0x20,0x50},{0x00,0x08,0x07,0x03,0x00},{0x00,0x1C,0x22,0x41,0x00},
  {0x00,0x41,0x22,0x1C,0x00},{0x2A,0x1C,0x7F,0x1C,0x2A},{0x08,0x08,0x3E,0x08,0x08},
  {0x00,0x80,0x70,0x30,0x00},{0x08,0x08,0x08,0x08,0x08},{0x00,0x00,0x60,0x60,0x00},
  {0x20,0x10,0x08,0x04,0x02},{0x3E,0x51,0x49,0x45,0x3E},{0x00,0x42,0x7F,0x40,0x00},
  {0x72,0x49,0x49,0x49,0x46},{0x21,0x41,0x49,0x4D,0x33},{0x18,0x14,0x12,0x7F,0x10},
  {0x27,0x45,0x45,0x45,0x39},{0x3C,0x4A,0x49,0x49,0x31},{0x41,0x21,0x11,0x09,0x07},
  {0x36,0x49,0x49,0x49,0x36},{0x46,0x49,0x49,0x29,0x1E},{0x00,0x00,0x14,0x00,0x00},
  {0x00,0x40,0x34,0x00,0x00},{0x00,0x08,0x14,0x22,0x41},{0x14,0x14,0x14,0x14,0x14},
  {0x00,0x41,0x22,0x14,0x08},{0x02,0x01,0x59,0x09,0x06},{0x3E,0x41,0x5D,0x59,0x4E},
  {0x7C,0x12,0x11,0x12,0x7C},{0x7F,0x49,0x49,0x49,0x36},{0x3E,0x41,0x41,0x41,0x22},
  {0x7F,0x41,0x41,0x41,0x3E},{0x7F,0x49,0x49,0x49,0x41},{0x7F,0x09,0x09,0x09,0x01},
  {0x3E,0x41,0x41,0x51,0x73},{0x7F,0x08,0x08,0x08,0x7F},{0x00,0x41,0x7F,0x41,0x00},
  {0x20,0x40,0x41,0x3F,0x01},{0x7F,0x08,0x14,0x22,0x41},{0x7F,0x40,0x40,0x40,0x40},
  {0x7F,0x02,0x1C,0x02,0x7F},{0x7F,0x04,0x08,0x10,0x7F},{0x3E,0x41,0x41,0x41,0x3E},
  {0x7F,0x09,0x09,0x09,0x06},{0x3E,0x41,0x51,0x21,0x5E},{0x7F,0x09,0x19,0x29,0x46},
  {0x26,0x49,0x49,0x49,0x32},{0x03,0x01,0x7F,0x01,0x03},{0x3F,0x40,0x40,0x40,0x3F},
  {0x1F,0x20,0x40,0x20,0x1F},{0x3F,0x40,0x38,0x40,0x3F},{0x63,0x14,0x08,0x14,0x63},
  {0x03,0x04,0x78,0x04,0x03},{0x61,0x59,0x49,0x4D,0x43},{0x00,0x7F,0x41,0x41,0x41},
  {0x02,0x04,0x08,0x10,0x20},{0x00,0x41,0x41,0x41,0x7F},{0x04,0x02,0x01,0x02,0x04},
  {0x40,0x40,0x40,0x40,0x40},{0x00,0x03,0x07,0x08,0x00},{0x20,0x54,0x54,0x78,0x40},
  {0x7F,0x28,0x44,0x44,0x38},{0x38,0x44,0x44,0x44,0x28},{0x38,0x44,0x44,0x28,0x7F},
  {0x38,0x54,0x54,0x54,0x18},{0x00,0x08,0x7E,0x09,0x02},{0x18,0xA4,0xA4,0x9C,0x78},
  {0x7F,0x08,0x04,0x04,0x78},{0x00,0x44,0x7D,0x40,0x00},{0x20,0x40,0x40,0x3D,0x00},
  {0x7F,0x10,0x28,0x44,0x00},{0x00,0x41,0x7F,0x40,0x00},{0x7C,0x04,0x78,0x04,0x78},
  {0x7C,0x08,0x04,0x04,0x78},{0x38,0x44,0x44,0x44,0x38},{0xFC,0x18,0x24,0x24,0x18},
  {0x18,0x24,0x24,0x18,0xFC},{0x7C,0x08,0x04,0x04,0x08},{0x48,0x54,0x54,0x54,0x24},
  {0x04,0x04,0x3F,0x44,0x24},{0x3C,0x40,0x40,0x20,0x7C},{0x1C,0x20,0x40,0x20,0x1C},
  {0x3C,0x40,0x30,0x40,0x3C},{0x44,0x28,0x10,0x28,0x44},{0x4C,0x90,0x90,0x90,0x7C},
  {0x44,0x64,0x54,0x4C,0x44},{0x00,0x08,0x36,0x41,0x00},{0x00,0x00,0x77,0x00,0x00},
  {0x00,0x41,0x36,0x08,0x00},{0x02,0x01,0x02,0x04,0x02},
};

static const uint8_t BAYER4[4][4] = {
  { 0,  8,  2, 10}, {12,  4, 14,  6}, { 3, 11,  1,  9}, {15,  7, 13,  5}};

uint16_t mix(uint16_t a, uint16_t b, int t) {
  if (t <= 0) return a;
  if (t >= 256) return b;
  int ar = a >> 11, ag = (a >> 5) & 63, ab = a & 31;
  int br = b >> 11, bg = (b >> 5) & 63, bb = b & 31;
  int r = ar + (((br - ar) * t) >> 8);
  int g = ag + (((bg - ag) * t) >> 8);
  int bl = ab + (((bb - ab) * t) >> 8);
  return (uint16_t)((r << 11) | (g << 5) | bl);
}

uint16_t scale(uint16_t c, int t) { return mix(0, c, t); }

void clear(uint16_t c) {
  for (int i = 0; i < W * H; i++) fb[i] = c;
}

void blend(int x, int y, uint16_t c, int a) {
  if ((unsigned)x < (unsigned)W && (unsigned)y < (unsigned)H) {
    uint16_t* p = &fb[y * W + x];
    *p = mix(*p, c, a);
  }
}

void hline(int x, int y, int w, uint16_t c) {
  if ((unsigned)y >= (unsigned)H) return;
  if (x < 0) { w += x; x = 0; }
  if (x + w > W) w = W - x;
  uint16_t* p = &fb[y * W + x];
  for (int i = 0; i < w; i++) p[i] = c;
}

void vline(int x, int y, int h, uint16_t c) {
  if ((unsigned)x >= (unsigned)W) return;
  if (y < 0) { h += y; y = 0; }
  if (y + h > H) h = H - y;
  for (int i = 0; i < h; i++) fb[(y + i) * W + x] = c;
}

void rect(int x, int y, int w, int h, uint16_t c) {
  for (int i = 0; i < h; i++) hline(x, y + i, w, c);
}

void frame(int x, int y, int w, int h, uint16_t c) {
  hline(x, y, w, c); hline(x, y + h - 1, w, c);
  vline(x, y, h, c); vline(x + w - 1, y, h, c);
}

void line(int x0, int y0, int x1, int y1, uint16_t c) {
  int dx = abs(x1 - x0), sx = x0 < x1 ? 1 : -1;
  int dy = -abs(y1 - y0), sy = y0 < y1 ? 1 : -1;
  int err = dx + dy;
  for (int guard = 0; guard < 1024; guard++) {
    px(x0, y0, c);
    if (x0 == x1 && y0 == y1) break;
    int e2 = 2 * err;
    if (e2 >= dy) { err += dy; x0 += sx; }
    if (e2 <= dx) { err += dx; y0 += sy; }
  }
}

void disc(int cx, int cy, int r, uint16_t c) {
  for (int dy = -r; dy <= r; dy++) {
    int dx = (int)sqrtf((float)(r * r - dy * dy) + 0.5f);
    hline(cx - dx, cy + dy, 2 * dx + 1, c);
  }
}

void ring(int cx, int cy, int r, uint16_t c) {
  int x = r, y = 0, err = 1 - r;
  while (x >= y) {
    px(cx + x, cy + y, c); px(cx - x, cy + y, c); px(cx + x, cy - y, c); px(cx - x, cy - y, c);
    px(cx + y, cy + x, c); px(cx - y, cy + x, c); px(cx + y, cy - x, c); px(cx - y, cy - x, c);
    y++;
    if (err < 0) err += 2 * y + 1; else { x--; err += 2 * (y - x) + 1; }
  }
}

bool bayer(int x, int y, int level) { return BAYER4[y & 3][x & 3] < level; }

void dither(int x, int y, int w, int h, uint16_t c, int level) {
  if (level <= 0) return;
  for (int j = 0; j < h; j++)
    for (int i = 0; i < w; i++)
      if (BAYER4[(y + j) & 3][(x + i) & 3] < level) px(x + i, y + j, c);
}

void glyph(int x, int y, char ch, uint16_t c) {
  if (ch < 0x20 || ch > 0x7E) ch = '?';
  const uint8_t* g = FONT[ch - 0x20];
  for (int col = 0; col < 5; col++) {
    uint8_t bits = g[col];
    for (int row = 0; row < 8; row++)
      if (bits & (1 << row)) px(x + col, y + row, c);
  }
}

int textN(int x, int y, const char* s, int n, uint16_t c) {
  for (int i = 0; i < n && s[i]; i++) { glyph(x, y, s[i], c); x += 6; }
  return x;
}

int text(int x, int y, const char* s, uint16_t c) { return textN(x, y, s, 1 << 20, c); }
int textWidth(const char* s) { return (int)strlen(s) * 6; }
void textCenter(int cx, int y, const char* s, uint16_t c) { text(cx - textWidth(s) / 2, y, s, c); }
void textRight(int xr, int y, const char* s, uint16_t c) { text(xr - textWidth(s) + 1, y, s, c); }

float vnoise(float x, float y, uint32_t seed) {
  int xi = (int)floorf(x), yi = (int)floorf(y);
  float fx = x - xi, fy = y - yi;
  fx = fx * fx * (3.0f - 2.0f * fx);
  fy = fy * fy * (3.0f - 2.0f * fy);
  float a = (hash2(xi, yi, seed) & 0xFFFF) / 65535.0f;
  float b = (hash2(xi + 1, yi, seed) & 0xFFFF) / 65535.0f;
  float c = (hash2(xi, yi + 1, seed) & 0xFFFF) / 65535.0f;
  float d = (hash2(xi + 1, yi + 1, seed) & 0xFFFF) / 65535.0f;
  return a + (b - a) * fx + (c - a) * fy + (a - b - c + d) * fx * fy;
}

}  // namespace mn
